# Keil uVision project 1701.uvproj, settings and files
target 1701 (MCS-51)
  device: SN8F5703 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF5) CLOCK(32000000) DPC
  output: WDT +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware\DELAY;.\Hardware\IO;.\Hardware\TM1668;.\Hardware\Timer;.\Hardware\INT;.\Hardware\PWM;.\Hardware\IIC;.\Hardware\EEPROM;.\Hardware\key;..\1701_2019.8.21;.\Hardware\BUZZER;.\Hardware\UART
  group 1701
    ./: STARTUP.A51 OPTIONS_SN8F5703.A51 main.c Config.h Function.c
  group HardWare
    ./Hardware/IO/: IO.c
    ./Hardware/DELAY/: Delay.c
    ./Hardware/TM1668/: TM1668.c
    ./Hardware/Timer/: timer.c
    ./Hardware/PWM/: PWM.c
    ./Hardware/IIC/: myiic.c
    ./Hardware/key/: key.c
    ./Hardware/BUZZER/: BUZZER.c
    ./Hardware/EEPROM/: EEPROM.c
